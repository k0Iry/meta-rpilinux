SUMMARY = "replace ntp.conf with sync server"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
