SUMMARY = "configure wireless connection"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
